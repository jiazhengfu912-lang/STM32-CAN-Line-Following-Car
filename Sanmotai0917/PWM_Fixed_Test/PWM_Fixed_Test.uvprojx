# Keil uVision project PWM_Fixed_Test.uvprojx, settings and files
target PWM_Fixed_Test (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: PWM_Fixed_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .;../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  group Application
    ./: main.c
    ../MDK-ARM/: startup_stm32f103xb.s
    ../Core/Src/: system_stm32f1xx.c
